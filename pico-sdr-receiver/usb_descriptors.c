#include "tusb.h"
#include <string.h>

tusb_desc_device_t const desc_device = {
    .bLength            = sizeof(tusb_desc_device_t),
    .bDescriptorType    = TUSB_DESC_DEVICE,
    .bcdUSB             = 0x0110,
    .bDeviceClass       = 0xEF,   // Misc Device
    .bDeviceSubClass    = 0x02,   // Common
    .bDeviceProtocol    = 0x01,   // IAD
    .bMaxPacketSize0    = 64,
    .idVendor           = 0xCAFE,
    .idProduct          = 0x4020, // Incremented to 0x4020 to bypass macOS cache
    .bcdDevice          = 0x0100,
    .iManufacturer      = 1,
    .iProduct           = 2,
    .iSerialNumber      = 3,
    .bNumConfigurations = 1
};

uint8_t const *tud_descriptor_device_cb(void) { return (uint8_t const *)&desc_device; }

// --- EXACT Raw Descriptor from Working Board (187 Bytes) ---
static uint8_t const desc_configuration[] = {
    0x09, 0x02, 187, 0, 0x04, 0x01, 0x00, 0xA0, 50,
    0x08, 0x0B, 0x00, 0x02, 0x02, 0x02, 0x00, 0x00,
    0x09, 0x04, 0x00, 0x00, 0x01, 0x02, 0x02, 0x00, 0x04,
    0x05, 0x24, 0x00, 0x20, 0x01,
    0x05, 0x24, 0x01, 0x00, 0x01,
    0x04, 0x24, 0x02, 0x06,
    0x05, 0x24, 0x06, 0x00, 0x01,
    0x07, 0x05, 0x83, 0x03, 0x08, 0x00, 0x01,
    0x09, 0x04, 0x01, 0x00, 0x02, 0x0A, 0x00, 0x00, 0x00,
    0x07, 0x05, 0x04, 0x02, 0x40, 0x00, 0x00,
    0x07, 0x05, 0x84, 0x02, 0x40, 0x00, 0x00,
    0x08, 0x0B, 0x02, 0x02, 0x01, 0x01, 0x00, 0x00,
    0x09, 0x04, 0x02, 0x00, 0x00, 0x01, 0x01, 0x00, 0x05,
    0x09, 0x24, 0x01, 0x00, 0x01, 43, 0x00, 0x01, 0x03,
    0x0C, 0x24, 0x02, 0x01, 0x03, 0x06, 0x03, 0x02, 0x03, 0x00, 0x00, 0x00,
    0x0D, 0x24, 0x06, 0x02, 0x01, 0x02, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
    0x09, 0x24, 0x03, 0x03, 0x01, 0x01, 0x01, 0x02, 0x00,
    0x09, 0x04, 0x03, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00,
    0x09, 0x04, 0x03, 0x01, 0x01, 0x01, 0x02, 0x00, 0x00,
    0x07, 0x24, 0x01, 0x03, 0x01, 0x01, 0x00,
    0x0B, 0x24, 0x02, 0x01, 0x02, 0x04, 24, 0x01, 0x80, 0xBB, 0x00,
    0x09, 0x05, 0x81, 0x05, 0x88, 0x01, 0x01, 0x00, 0x00,
    0x07, 0x25, 0x01, 0x01, 0x01, 0x01, 0x00
};

uint8_t const *tud_descriptor_configuration_cb(uint8_t index) { (void)index; return desc_configuration; }

static char const *const string_desc_arr[] = {
    (const char[]){0x09, 0x04},
    "Joseph Pennock",
    "Final SDR Audio",
    "000008", 
    "CDC Interface",
    "Audio Interface"
};

static uint16_t _desc_str[32];
uint16_t const *tud_descriptor_string_cb(uint8_t index, uint16_t langid) {
    (void)langid; uint8_t chr_count;
    if (index == 0) { memcpy(&_desc_str[1], string_desc_arr[0], 2); chr_count = 1; }
    else {
        if (index >= sizeof(string_desc_arr) / sizeof(string_desc_arr[0])) return NULL;
        const char *str = string_desc_arr[index];
        chr_count = strlen(str);
        if (chr_count > 31) chr_count = 31;
        for (uint8_t i = 0; i < chr_count; i++) _desc_str[1 + i] = str[i];
    }
    _desc_str[0] = (TUSB_DESC_STRING << 8) | (2 * chr_count + 2);
    return _desc_str;
}
